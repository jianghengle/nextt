<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>andersen</value></param>
<param><key>value</key><value>"serial=3148587"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>avtl</value></param>
<param><key>value</key><value>"serial=3149392"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>434e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fic</value></param>
<param><key>value</key><value>"serial=3148583"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oldfather</value></param>
<param><key>value</key><value>"serial=3148585"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wsec</value></param>
<param><key>value</key><value>"serial=3149391"</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>[2,1,1,5]</value></param>
<param><key>label1</key><value>OFH</value></param>
<param><key>label2</key><value>WSEC</value></param>
<param><key>label3</key><value>AH</value></param>
<param><key>label4</key><value>FIC</value></param>
<param><key>label5</key><value>AV &amp; Vine</value></param>
<param><key>name</key><value>"RX Spectrum"</value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>[1,1,1,1]</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>label1</key><value>OFH</value></param>
<param><key>name</key><value>"OFH"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>[1,2,1,1]</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>label1</key><value>OFH</value></param>
<param><key>name</key><value>"WSEC"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>[1,3,1,1]</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>label1</key><value>OFH</value></param>
<param><key>name</key><value>"AH"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>[1,4,1,1]</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>label1</key><value>OFH</value></param>
<param><key>name</key><value>"FIC"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_5</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>[1,5,1,1]</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>label1</key><value>OFH</value></param>
<param><key>name</key><value>"AV &amp; Vine"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>100</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>oldfather</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>100</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>wsec</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_1</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>100</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>andersen</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_2</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>100</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>fic</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_5</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>100</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>avtl</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_2</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_2</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_5</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_5</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
